# Keil uVision project cc6801.uvprojx, settings and files
target FPGA_M0p (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: FPGA_M0p +hex
  AfterMake: fromelf.exe --bincombined --output .\Objects\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c misc: --no_inline --no_multifile -DMSC_CLOCK
  c include: ..\..\cfg\project;..\..\inc;..\..\inc\CMSIS;..\..\mmi;..\..\platform\init\inc;..\..\platform\asic\6801;..\..\platform\drvi;..\..\module\mems;..\..\module\oled;..\..\service\sw_timer;..\..\service\fifo;..\..\service\uart;..\..\service\tracer;..\..\test;..\..\test\ext
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_eflash.sct
  group asic
    ../../platform/asic/6801/: adc.c aes.c clock.c dmic.c dmu.c eflash.c gpio.c i2c.c i2s.c pwm.c spim.c rtc.c uart.c wdt.c wktm.c
  group drvi
    ../../platform/drvi/: drvi_aes.c drvi_i2c.c drvi_init.c drvi_pwm.c drvi_spi.c drvi_uart.c drvi_wktm.c drvi_rtc.c
  group init
    ../../platform/init/src/: arch_main.c system_init.c
  group mmi
    ../../mmi/: appDisplay.c font.c icon.c
  group module
    ../../module/mems/: acc_lsm6ds3.c acc_null.c gyr_null.c mag_ak09912.c mag_null.c
  group oled
    ../../module/oled/: ssd1306.c ssd1306_128x32.c
  group service
    ../../service/fifo/: app_fifo.c
    ../../service/uart/: app_uart_fifo.c retarget.c
    ../../service/sw_timer/: sw_timer.c
    ../../service/tracer/: tracer.c
    ../../service/low_power/: low_power.c
  group test
    ../../test/src/: test_aes.c test_main.c test_uart.c test_spi.c test_i2c.c test_clock.c test_dhry_1.c test_dhry_2.c
target FPGA_M4f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: FPGA_M4f +hex
  AfterMake: fromelf.exe --bincombined --output .\Objects\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\cfg\project;..\..\inc;..\..\inc\CMSIS;..\..\mmi;..\..\platform\asic\6801;..\..\platform\drvi;..\..\platform\init\inc;..\..\module\mems;..\..\module\oled;..\..\service\sw_timer;..\..\service\fifo;..\..\service\uart;..\..\service\tracer;..\..\test;..\..\test\ext
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_eflash.sct
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1
