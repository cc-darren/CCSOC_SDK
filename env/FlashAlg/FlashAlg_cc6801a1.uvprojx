# Keil uVision project FlashAlg_cc6801a1.uvprojx, settings and files
target cc6801_M0p (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: CC6801_M0P_FlashAlg
  BeforeMake: cmd.exe /C mkdir ".\release\"
  AfterMake: cmd.exe /C copy ".\obj\%L" ".\release\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EFLASH_ASYNCMODE=0
  c include: ..\..\inc;..\..\inc\CMSIS;..\..\platform\drvi;..\..\platform\asic\6801a1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./src/: FlashPrg.c
  group Device Description
    ./src/: FlashDev.c
  group system
    ../../platform/asic/6801a1/: eflash.c
target cc6801_M4f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: CC6801_M4F_FlashAlg
  BeforeMake: cmd.exe /C mkdir ".\release\"
  AfterMake: cmd.exe /C copy ".\obj\%L" ".\release\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: EFLASH_ASYNCMODE=0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target cc6801_M0p_Protect (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: CC6801_M0P_FlashAlgProtect
  BeforeMake: cmd.exe /C mkdir ".\release\"
  AfterMake: cmd.exe /C copy ".\obj\%L" ".\release\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: EFLASH_ASYNCMODE=0 EF_PROTECTED
  c include: ..\..\inc;..\..\inc\CMSIS;..\..\platform\drvi;..\..\platform\asic\6801a0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target cc6801_M4f_Protect (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: CC6801_M4F_FlashAlgProtect
  BeforeMake: cmd.exe /C mkdir ".\release\"
  AfterMake: cmd.exe /C copy ".\obj\%L" ".\release\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: EFLASH_ASYNCMODE=0 EF_PROTECTED
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
