# Keil uVision project cc6801b0.uvprojx, settings and files
target FPGA_M0p (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: FPGA_M0p +hex
  AfterMake: ..\bin\afterbuild.bat @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: FPGA CC6801B0
  c misc: --no_inline --no_multifile -DMSC_CLOCK
  c include: .\config;..\..\cfg\project;..\..\inc;..\..\inc\CMSIS;..\..\app\Display;..\..\platform\init\inc;..\..\platform\asic\6801b0;..\..\platform\drvi;..\..\module\flash;..\..\module\mems;..\..\module\oled;..\..\module\ppg;..\..\service\fifo;..\..\service\tracer;..\..\test;..\..\test\inc
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_eflash.sct
  group app
    ../../app/Display/: appDisplay.c font.c icon.c
  group 6801b0
    ../../platform/asic/6801b0/: adc.c aes.c clock.c dmic.c eflash.c gpio.c i2c.c i2s.c lowpower.c pwm.c spim.c rtc.c uart.c wdt.c wktm.c system_init.c
  group drvi
    ../../platform/drvi/: drvi_aes.c drvi_i2c.c drvi_init.c drvi_pwm.c drvi_spi.c drvi_uart.c drvi_wktm.c drvi_rtc.c
  group module
    ../../module/mems/: acc_null.c mag_null.c gyr_null.c acc_lsm6ds3.c mag_ak09912.c gyr_lsm6ds3.c
    ../../module/flash/: flash_null.c flash_winbond.c
    ../../module/ppg/: ppg_pah8002.c
  group oled
    ../../module/oled/: ssd1306.c ssd1306_128x32.c
  group service
    ../../service/tracer/: tracer.c
  group test
    ../../test/src/: test_adc.c test_aes.c test_clock.c test_dhry_1.c test_dhry_2.c test_eflash.c test_i2c.c test_intg.c test_main.c test_retram.c test_spi.c test_uart.c test_uartrx.c test_wdt.c test_mem.c
  group startup
    ../../platform/asic/6801b0/bootcode/: startup_ARMCortexM.s
    ./: arch_main.c
target FPGA_M4f (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: FPGA_M4f +hex
  AfterMake: ..\bin\afterbuild.bat @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FPGA CC6801B0
  c include: .\config;..\..\cfg\project;..\..\inc;..\..\inc\CMSIS;..\..\app\Display;..\..\platform\asic\6801b0;..\..\platform\drvi;..\..\platform\init\inc;..\..\module\flash;..\..\module\mems;..\..\module\oled;..\..\module\ppg;..\..\service\fifo;..\..\service\tracer;..\..\test;..\..\test\inc
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_eflash.sct
target EVB_M0p (5060183::V5.06 update 2 (build 183)::..\Backup.001\ARM\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: EVB_M0p +hex
  AfterMake: ..\bin\afterbuild.bat @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: EVB605A CC6801B0
  c misc: --no_inline --no_multifile -DMSC_CLOCK
  c include: .\config;..\..\cfg\project;..\..\inc;..\..\inc\CMSIS;..\..\app\Display;..\..\platform\init\inc;..\..\platform\asic\6801b0;..\..\platform\drvi;..\..\module\flash;..\..\module\mems;..\..\module\oled;..\..\module\ppg;..\..\service\experimental_section_vars;..\..\service\fifo;..\..\service\fstorage;..\..\service\tracer;..\..\service\uart_ring;..\..\test;..\..\test\inc
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_ram.sct
target EVB_M4f (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: EVB_M4f +hex
  AfterMake: ..\bin\afterbuild.bat @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EVB605A CC6801B0
  c include: .\config;..\..\cfg\project;..\..\inc;..\..\inc\CMSIS;..\..\app\Display;..\..\platform\asic\6801b0;..\..\platform\drvi;..\..\platform\init\inc;..\..\module\flash;..\..\module\mems;..\..\module\oled;..\..\module\ppg;..\..\service\experimental_section_vars;..\..\service\fifo;..\..\service\fstorage;..\..\service\tracer;..\..\service\uart_ring;..\..\test;..\..\test\inc
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_eflash.sct
target DVK_M0p (5060183::V5.06 update 2 (build 183)::..\Backup.001\ARM\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: DVK_M0p +hex
  AfterMake: ..\bin\afterbuild.bat @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DVK403A CC6801B0
  c misc: --no_inline --no_multifile -DMSC_CLOCK
  c include: as above
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_ram.sct
target DVK_M4F (5060183::V5.06 update 2 (build 183)::..\Backup.001\ARM\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: DVK_M4f +hex
  AfterMake: ..\bin\afterbuild.bat @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK403A CC6801B0
  c include: as above
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_ram.sct
target DVK_DC_M0p (5060183::V5.06 update 2 (build 183)::..\Backup.001\ARM\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: DC_M0p +hex
  AfterMake: ..\bin\afterbuild.bat @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DVK_DC404A CC6801B0
  c misc: --no_inline --no_multifile -DMSC_CLOCK
  c include: as above
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_ram.sct
target DVK_DC_M4F (5060183::V5.06 update 2 (build 183)::..\Backup.001\ARM\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: as above
  output: DC_M4f +hex
  AfterMake: ..\bin\afterbuild.bat @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK_DC404A CC6801B0
  c include: as above
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_ram.sct
