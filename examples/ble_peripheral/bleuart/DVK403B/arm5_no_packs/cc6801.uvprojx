# Keil uVision project cc6801.uvprojx, settings and files
target DVK403B_M0p (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: DVK403B_M0p +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK403B CC6801B1
  c misc: --preinclude ..\..\..\..\..\cfg\project\project.h --preinclude ..\..\..\..\..\inc\global.h
  c include: ..\..\..\..\..\cfg\project;..\..\..\..\..\inc;..\..\..\..\..\inc\CMSIS;..\..\..\..\..\platform\init\inc;..\..\..\..\..\platform\asic\6801b1;..\..\..\..\..\platform\drvi;..\..\..\..\..\service\tracer;..\..\..\..\..\service\uart_ring;..\..\..\..\..\service\sw_timer;..\..\..\..\..\ble\inc;..\..\..\..\..\ble\ip\ahi\api;..\..\..\..\..\ble\ip\ble\hl\api;..\..\..\..\..\ble\ip\ble\hl\inc;..\..\..\..\..\ble\ip\ble\hl\src\gap;..\..\..\..\..\ble\ip\ble\hl\src\gap\gapc;..\..\..\..\..\ble\ip\ble\hl\src\gap\gapm;..\..\..\..\..\ble\ip\ble\hl\src\gap\smpc;..\..\..\..\..\ble\ip\ble\hl\src\gap\smpm;..\..\..\..\..\ble\ip\ble\hl\src\gatt;..\..\..\..\..\ble\ip\ble\hl\src\gatt\attc;..\..\..\..\..\ble\ip\ble\hl\src\gatt\attm;..\..\..\..\..\ble\ip\ble\hl\src\gatt\atts;..\..\..\..\..\ble\ip\ble\hl\src\gatt\gattc;..\..\..\..\..\ble\ip\ble\hl\src\gatt\gattm;..\..\..\..\..\ble\ip\ble\hl\src\l2c\l2cc;..\..\..\..\..\ble\ip\ble\hl\src\l2c\l2cm;..\..\..\..\..\ble\ip\ble\hl\src\rwble_hl;..\..\..\..\..\ble\ip\ble\ll\src\em;..\..\..\..\..\ble\ip\ble\ll\src\llc;..\..\..\..\..\ble\ip\ble\ll\src\lld;..\..\..\..\..\ble\ip\ble\ll\src\llm;..\..\..\..\..\ble\ip\ble\ll\src\rwble;..\..\..\..\..\ble\ip\ble\profiles\anp;..\..\..\..\..\ble\ip\ble\profiles\anp\anpc\api;..\..\..\..\..\ble\ip\ble\profiles\anp\anps\api;..\..\..\..\..\ble\ip\ble\profiles\bas\basc\api;..\..\..\..\..\ble\ip\ble\profiles\bas\bass\api;..\..\..\..\..\ble\ip\ble\profiles\blp;..\..\..\..\..\ble\ip\ble\profiles\blp\blpc\api;..\..\..\..\..\ble\ip\ble\profiles\blp\blps\api;..\..\..\..\..\ble\ip\ble\profiles\cpp;..\..\..\..\..\ble\ip\ble\profiles\cpp\cppc\api;..\..\..\..\..\ble\ip\ble\profiles\cpp\cpps\api;..\..\..\..\..\ble\ip\ble\profiles\cscp;..\..\..\..\..\ble\ip\ble\profiles\cscp\cscpc\api;..\..\..\..\..\ble\ip\ble\profiles\cscp\cscps\api;..\..\..\..\..\ble\ip\ble\profiles\dis\disc\api;..\..\..\..\..\ble\ip\ble\profiles\dis\diss\api;..\..\..\..\..\ble\ip\ble\profiles\find;..\..\..\..\..\ble\ip\ble\profiles\find\findl\api;..\..\..\..\..\ble\ip\ble\profiles\find\findt\api;..\..\..\..\..\ble\ip\ble\profiles\glp;..\..\..\..\..\ble\ip\ble\profiles\glp\glpc\api;..\..\..\..\..\ble\ip\ble\profiles\glp\glps\api;..\..\..\..\..\ble\ip\ble\profiles\hogp;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogpbh\api;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogpd\api;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogprh\api;..\..\..\..\..\ble\ip\ble\profiles\hrp;..\..\..\..\..\ble\ip\ble\profiles\hrp\hrpc\api;..\..\..\..\..\ble\ip\ble\profiles\hrp\hrps\api;..\..\..\..\..\ble\ip\ble\profiles\htp;..\..\..\..\..\ble\ip\ble\profiles\htp\htpc\api;..\..\..\..\..\ble\ip\ble\profiles\htp\htpt\api;..\..\..\..\..\ble\ip\ble\profiles\lan;..\..\..\..\..\ble\ip\ble\profiles\lan\lanc\api;..\..\..\..\..\ble\ip\ble\profiles\lan\lans\api;..\..\..\..\..\ble\ip\ble\profiles\pasp;..\..\..\..\..\ble\ip\ble\profiles\pasp\paspc\api;..\..\..\..\..\ble\ip\ble\profiles\pasp\pasps\api;..\..\..\..\..\ble\ip\ble\profiles\prox\proxm\api;..\..\..\..\..\ble\ip\ble\profiles\prox\proxr\api;..\..\..\..\..\ble\ip\ble\profiles\rscp;..\..\..\..\..\ble\ip\ble\profiles\rscp\rscpc\api;..\..\..\..\..\ble\ip\ble\profiles\rscp\rscps\api;..\..\..\..\..\ble\ip\ble\profiles\scpp;..\..\..\..\..\ble\ip\ble\profiles\scpp\scppc\api;..\..\..\..\..\ble\ip\ble\profiles\scpp\scpps\api;..\..\..\..\..\ble\ip\ble\profiles\tip;..\..\..\..\..\ble\ip\ble\profiles\tip\tipc\api;..\..\..\..\..\ble\ip\ble\profiles\tip\tips\api;..\..\..\..\..\ble\ip\ea\api;..\..\..\..\..\ble\ip\em\api;..\..\..\..\..\ble\ip\hci\api;..\..\..\..\..\ble\modules\app\api;..\..\..\..\..\ble\modules\common\api;..\..\..\..\..\ble\modules\dbg\api;..\..\..\..\..\ble\modules\display\api;..\..\..\..\..\ble\modules\ecc_p256\api;..\..\..\..\..\ble\modules\h4tl\api;..\..\..\..\..\ble\modules\ke\api;..\..\..\..\..\ble\modules\ke\src;..\..\..\..\..\ble\modules\nvds\api;..\..\..\..\..\ble\modules\rf\api;..\..\..\..\..\ble\modules\rwip\api;..\..\..\..\..\ble\modules\app\src;..\..\..\..\..\ble\ip\ble\profiles\ota\otat;..\..\..\..\..\ble\ip\ble\profiles\ota\otat\api;..\..\..\..\..\ble\ip\ble\profiles\ota\otat\src;..\..\..\..\..\ble\ip\ble\profiles\bleuarts\api;..\..\..\..\..\ble\ip\ble\profiles\bleuarts\src;..\..\..\..\..\app\ble_mgr;..\..\..\..\..\platform\bootloader;..\config;..\..\..\bleuarts
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\eflash.sct
  link misc: ..\..\..\..\..\platform\asic\6801b1\rom_symdef_M0.txt --keep=jump_table.o(jump_table_mem_area) --diag_suppress=L6314
  group 6801b1
    ../../../../../platform/asic/6801b1/: clock.c eflash.c gpio.c i2c.c system_init.c uart.c wdt.c wktm.c
  group drvi
    ../../../../../platform/drvi/: drvi_init.c drvi_uart.c drvi_wktm.c
  group module
    ../../../../../module/mems/: acc_null.c gyr_null.c mag_null.c
    ../../../../../module/touch/: touch_null.c
  group service
    ../../../../../service/: service_lib_M0.lib
    ../../../../../service/tracer/: tracer.c
  group startup
    ../../: arch_main.c
    ../../../../../platform/asic/6801b1/bootcode/: startup_ARMCortexM.s
    ../../../../../platform/init/src/: jump_table.c
  group app
    ../../../../../app/ble_mgr/: ble_mgr.c
  group ble_app
    ../../../../../ble/modules/app/src/: app.c app_batt.c app_dis.c app_sec.c app_task.c app_bleuarts.c
  group ble_drv
    ../../../../../ble/modules/rf/src/: rf_atlas.c
    ../../../../../ble/modules/nvds/src/: nvds.c
  group ble_profiles
    ../../../../../ble/ip/ble/profiles/bas/bass/src/: bass_task.c
    ../../../../../ble/ip/ble/profiles/dis/diss/src/: diss_task.c diss.c
    ../../../../../ble/ip/ble/hl/src/prf/: prf.c prf_utils.c
    ../../../../../ble/ip/ble/profiles/bleuarts/src/: bleuarts.c bleuarts_task.c
target DVK403B_M4f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: DVK403B_M4f +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK403B CC6801B1
  c misc: as above
  c include: ..\..\..\..\..\cfg\project;..\..\..\..\..\inc;..\..\..\..\..\inc\CMSIS;..\..\..\..\..\platform\init\inc;..\..\..\..\..\platform\asic\6801b1;..\..\..\..\..\platform\drvi;..\..\..\..\..\service\tracer;..\..\..\..\..\service\uart_ring;..\..\..\..\..\service\sw_timer;..\..\..\..\..\ble\inc;..\..\..\..\..\ble\ip\ahi\api;..\..\..\..\..\ble\ip\ble\hl\api;..\..\..\..\..\ble\ip\ble\hl\inc;..\..\..\..\..\ble\ip\ble\hl\src\gap;..\..\..\..\..\ble\ip\ble\hl\src\gap\gapc;..\..\..\..\..\ble\ip\ble\hl\src\gap\gapm;..\..\..\..\..\ble\ip\ble\hl\src\gap\smpc;..\..\..\..\..\ble\ip\ble\hl\src\gap\smpm;..\..\..\..\..\ble\ip\ble\hl\src\gatt;..\..\..\..\..\ble\ip\ble\hl\src\gatt\attc;..\..\..\..\..\ble\ip\ble\hl\src\gatt\attm;..\..\..\..\..\ble\ip\ble\hl\src\gatt\atts;..\..\..\..\..\ble\ip\ble\hl\src\gatt\gattc;..\..\..\..\..\ble\ip\ble\hl\src\gatt\gattm;..\..\..\..\..\ble\ip\ble\hl\src\l2c\l2cc;..\..\..\..\..\ble\ip\ble\hl\src\l2c\l2cm;..\..\..\..\..\ble\ip\ble\hl\src\rwble_hl;..\..\..\..\..\ble\ip\ble\ll\src\em;..\..\..\..\..\ble\ip\ble\ll\src\llc;..\..\..\..\..\ble\ip\ble\ll\src\lld;..\..\..\..\..\ble\ip\ble\ll\src\llm;..\..\..\..\..\ble\ip\ble\ll\src\rwble;..\..\..\..\..\ble\ip\ble\profiles\anp;..\..\..\..\..\ble\ip\ble\profiles\anp\anpc\api;..\..\..\..\..\ble\ip\ble\profiles\anp\anps\api;..\..\..\..\..\ble\ip\ble\profiles\bas\basc\api;..\..\..\..\..\ble\ip\ble\profiles\bas\bass\api;..\..\..\..\..\ble\ip\ble\profiles\blp;..\..\..\..\..\ble\ip\ble\profiles\blp\blpc\api;..\..\..\..\..\ble\ip\ble\profiles\blp\blps\api;..\..\..\..\..\ble\ip\ble\profiles\cpp;..\..\..\..\..\ble\ip\ble\profiles\cpp\cppc\api;..\..\..\..\..\ble\ip\ble\profiles\cpp\cpps\api;..\..\..\..\..\ble\ip\ble\profiles\cscp;..\..\..\..\..\ble\ip\ble\profiles\cscp\cscpc\api;..\..\..\..\..\ble\ip\ble\profiles\cscp\cscps\api;..\..\..\..\..\ble\ip\ble\profiles\dis\disc\api;..\..\..\..\..\ble\ip\ble\profiles\dis\diss\api;..\..\..\..\..\ble\ip\ble\profiles\find;..\..\..\..\..\ble\ip\ble\profiles\find\findl\api;..\..\..\..\..\ble\ip\ble\profiles\find\findt\api;..\..\..\..\..\ble\ip\ble\profiles\glp;..\..\..\..\..\ble\ip\ble\profiles\glp\glpc\api;..\..\..\..\..\ble\ip\ble\profiles\glp\glps\api;..\..\..\..\..\ble\ip\ble\profiles\hogp;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogpbh\api;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogpd\api;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogprh\api;..\..\..\..\..\ble\ip\ble\profiles\hrp;..\..\..\..\..\ble\ip\ble\profiles\hrp\hrpc\api;..\..\..\..\..\ble\ip\ble\profiles\hrp\hrps\api;..\..\..\..\..\ble\ip\ble\profiles\htp;..\..\..\..\..\ble\ip\ble\profiles\htp\htpc\api;..\..\..\..\..\ble\ip\ble\profiles\htp\htpt\api;..\..\..\..\..\ble\ip\ble\profiles\lan;..\..\..\..\..\ble\ip\ble\profiles\lan\lanc\api;..\..\..\..\..\ble\ip\ble\profiles\lan\lans\api;..\..\..\..\..\ble\ip\ble\profiles\pasp;..\..\..\..\..\ble\ip\ble\profiles\pasp\paspc\api;..\..\..\..\..\ble\ip\ble\profiles\pasp\pasps\api;..\..\..\..\..\ble\ip\ble\profiles\prox\proxm\api;..\..\..\..\..\ble\ip\ble\profiles\prox\proxr\api;..\..\..\..\..\ble\ip\ble\profiles\rscp;..\..\..\..\..\ble\ip\ble\profiles\rscp\rscpc\api;..\..\..\..\..\ble\ip\ble\profiles\rscp\rscps\api;..\..\..\..\..\ble\ip\ble\profiles\scpp;..\..\..\..\..\ble\ip\ble\profiles\scpp\scppc\api;..\..\..\..\..\ble\ip\ble\profiles\scpp\scpps\api;..\..\..\..\..\ble\ip\ble\profiles\tip;..\..\..\..\..\ble\ip\ble\profiles\tip\tipc\api;..\..\..\..\..\ble\ip\ble\profiles\tip\tips\api;..\..\..\..\..\ble\ip\ea\api;..\..\..\..\..\ble\ip\em\api;..\..\..\..\..\ble\ip\hci\api;..\..\..\..\..\ble\modules\app\api;..\..\..\..\..\ble\modules\common\api;..\..\..\..\..\ble\modules\dbg\api;..\..\..\..\..\ble\modules\display\api;..\..\..\..\..\ble\modules\ecc_p256\api;..\..\..\..\..\ble\modules\h4tl\api;..\..\..\..\..\ble\modules\ke\api;..\..\..\..\..\ble\modules\ke\src;..\..\..\..\..\ble\modules\nvds\api;..\..\..\..\..\ble\modules\rf\api;..\..\..\..\..\ble\modules\rwip\api;..\..\..\..\..\ble\modules\app\src;..\..\..\..\..\ble\ip\ble\profiles\ota\otat;..\..\..\..\..\ble\ip\ble\profiles\ota\otat\api;..\..\..\..\..\ble\ip\ble\profiles\ota\otat\src;..\..\..\..\..\app\ble_mgr;..\..\..\..\..\platform\bootloader;..\config;..\..\..\bleuarts;..\..\..\..\..\ble\ip\ble\profiles\bleuarts\api;..\..\..\..\..\ble\ip\ble\profiles\bleuarts\src
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\eflash.sct
  link misc: ..\..\..\..\..\platform\asic\6801b1\rom_symdef_M4.txt --keep=jump_table.o(jump_table_mem_area) --diag_suppress=L6314
