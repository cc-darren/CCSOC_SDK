# Keil uVision project cc6801b0.uvprojx, settings and files
target EVB605A_M0p (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: EVB605A_M0p +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK403A CC6801B0
  c include: ..\config;..\..\..\..\..\cfg\project;..\..\..\..\..\inc;..\..\..\..\..\inc\CMSIS;..\..\..\..\..\platform\asic\6801b0;..\..\..\..\..\platform\drvi;..\..\..\..\..\platform\init\inc;..\..\..\..\..\service\tracer;..\..\..\..\..\platform\rtos\freertos\include;..\..\..\..\..\platform\rtos\freertos\portable\RVDS\ARM_CM0
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\eflash.sct
  link misc: --diag_suppress=L6314
  group 6801b0
    ../../../../../platform/asic/6801b0/: adc.c aes.c clock.c dmic.c dmu.c eflash.c gpio.c i2c.c i2s.c lowpower.c pwm.c spim.c rtc.c uart.c wdt.c wktm.c system_init.c
  group drvi
    ../../../../../platform/drvi/: drvi_aes.c drvi_i2c.c drvi_init.c drvi_pwm.c drvi_spi.c drvi_uart.c drvi_wktm.c drvi_rtc.c
  group service
    ../../../../../service/tracer/: tracer.c
  group rtos
    ../../../../../platform/rtos/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../platform/rtos/freertos/portable/MemMang/: heap_4.c
    ../../../../../platform/rtos/freertos/portable/Common/: mpu_wrappers.c
    ../../../../../platform/rtos/freertos/portable/RVDS/ARM_CM0/: port_CM0.c
    ../../../../../platform/rtos/freertos/portable/RVDS/ARM_CM4F/: port_CM4F.c
  group startup
    ../../../../../platform/asic/6801b0/bootcode/: startup_ARMCortexM.s
    ../../: arch_main.c
    ./: task_table.c
target EVB605A_M4f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: EVB605A_M4f +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EVB605A CC6801B0
  c include: ..\config;..\..\..\..\..\cfg\project;..\..\..\..\..\inc;..\..\..\..\..\inc\CMSIS;..\..\..\..\..\platform\asic\6801b0;..\..\..\..\..\platform\drvi;..\..\..\..\..\platform\init\inc;..\..\..\..\..\service\tracer;..\..\..\..\..\platform\rtos\freertos\include;..\..\..\..\..\platform\rtos\freertos\portable\RVDS\ARM_CM4F
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\eflash.sct
  link misc: --diag_suppress=L6314
target DVK403A_M0p (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: DVK403A_M0p +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK403A CC6801B0
  c include: as above
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\eflash.sct
  link misc: --diag_suppress=L6314
target DVK403A_M4f (5060183::V5.06 update 2 (build 183)::..\Backup.001\ARM\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: DVK403A_M4f +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK403A CC6801B0
  c include: as above
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\eflash.sct
  link misc: --diag_suppress=L6314
