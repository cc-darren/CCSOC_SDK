# Keil uVision project cc6801.uvprojx, settings and files
target DVK403B_M0p (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: DVK403B_M0p +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DVK403B CC6801B1
  c misc: --no_inline --no_multifile -DMSC_CLOCK
  c include: ..\config;..\..\..\..\..\cfg\project;..\..\..\..\..\inc;..\..\..\..\..\inc\CMSIS;..\..\..\..\..\app\Display;..\..\..\..\..\platform\init\inc;..\..\..\..\..\platform\asic\6801b1;..\..\..\..\..\platform\drvi;..\..\..\..\..\module\flash;..\..\..\..\..\module\mems;..\..\..\..\..\module\oled;..\..\..\..\..\module\ppg;..\..\..\..\..\service\experimental_section_vars;..\..\..\..\..\service\fifo;..\..\..\..\..\service\fstorage;..\..\..\..\..\service\tracer;..\..\..\..\..\service\uart_ring;..\..\..\..\..\test;..\..\..\..\..\test\inc
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\eflash.sct
  group 6801b1
    ../../../../../platform/asic/6801b1/: clock.c spim.c system_init.c uart.c gpio.c
  group drvi
    ../../../../../platform/drvi/: drvi_init.c drvi_spi.c drvi_uart.c
  group module
    ../../../../../module/mems/: acc_lsm6ds3.c gyr_lsm6ds3.c
  group service
    ../../../../../service/tracer/: tracer.c
  group startup
    ../../../../../platform/asic/6801b1/bootcode/: startup_ARMCortexM.s
    ../../: arch_main.c
target DVK403B_M4f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: DVK403B_M4f +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK403B CC6801B1
  c include: ..\config;..\..\..\..\..\cfg\project;..\..\..\..\..\inc;..\..\..\..\..\inc\CMSIS;..\..\..\..\..\app\Display;..\..\..\..\..\platform\asic\6801b1;..\..\..\..\..\platform\drvi;..\..\..\..\..\platform\init\inc;..\..\..\..\..\module\flash;..\..\..\..\..\module\mems;..\..\..\..\..\module\oled;..\..\..\..\..\module\ppg;..\..\..\..\..\service\experimental_section_vars;..\..\..\..\..\service\fifo;..\..\..\..\..\service\fstorage;..\..\..\..\..\service\tracer;..\..\..\..\..\service\uart_ring;..\..\..\..\..\test;..\..\..\..\..\test\inc
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\eflash.sct
target DVK_M0p (5060183::V5.06 update 2 (build 183)::..\Backup.001\ARM\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: DVK_M0p +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DVK403A CC6801B1
  c misc: --no_inline --no_multifile -DMSC_CLOCK
  c include: as above
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\eflash.sct
target DVK_M4F (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: DVK_M4f +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK403A CC6801B1
  c include: as above
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\eflash.sct
target DVK_DC_M0p (5060183::V5.06 update 2 (build 183)::..\Backup.001\ARM\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: DC_M0p +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DVK_DC404A CC6801B1
  c misc: --no_inline --no_multifile -DMSC_CLOCK
  c include: as above
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\eflash.sct
target DVK_DC_M4F (5060183::V5.06 update 2 (build 183)::..\Backup.001\ARM\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: DC_M4f +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK_DC404A CC6801B1
  c include: as above
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\eflash.sct
