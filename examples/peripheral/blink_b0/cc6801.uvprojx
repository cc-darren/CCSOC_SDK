# Keil uVision project cc6801.uvprojx, settings and files
target EVB_M4f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: FPGA_M4f +hex
  AfterMake: fromelf.exe --bincombined --output .\Objects\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EVB605A CC6801B0
  c include: .\config;..\..\..\cfg\project;..\..\..\inc;..\..\..\inc\CMSIS;..\..\..\platform\init\inc;..\..\..\platform\asic\6801b0;..\..\..\platform\drvi;..\..\..\service\tracer;..\..\..\service\uart_ring;..\..\..\service\sw_timer;..\..\..\platform\rtos\freertos\include;..\..\..\platform\rtos\freertos\portable\RVDS\ARM_CM4F
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_ram.sct
  group 6801b0
    ../../../platform/asic/6801b0/: clock.c gpio.c uart.c system_init.c i2c.c
  group drvi
    ../../../platform/drvi/: drvi_init.c drvi_uart.c
  group module
    ../../../module/mems/: acc_null.c gyr_null.c mag_null.c
    ../../../module/touch/: touch_null.c
  group service
    ../../../service/: service_lib_M0.lib
    ../../../service/tracer/: tracer.c
  group startup
    ./: arch_main.c
    ../../../platform/asic/6801b0/bootcode/: startup_ARMCortexM.s
  group rtos
    ../../../platform/rtos/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../platform/rtos/freertos/portable/MemMang/: heap_4.c
    ../../../platform/rtos/freertos/portable/RVDS/ARM_CM4F/: port.c
