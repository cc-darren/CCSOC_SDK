# Keil uVision project cc6801.uvprojx, settings and files
target FPGA_M0p (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: FPGA_M0p +hex
  AfterMake: afterbuild.bat @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: EVB CC6801B0
  c misc: --no_multifile
  c include: ..\..\..\inc;..\..\..\inc\CMSIS;.\config;..\..\..\cfg\project;..\..\..\platform\asic\6801b0;..\..\..\platform\asic\6801b0\config;..\..\..\platform\drvi;..\..\..\module\mems;..\..\..\module\oled;..\..\..\service\tracer
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\FPGA_eflash.sct
  group asic
    ../../../platform/asic/6801b0/: gpio.c rtc.c wktm.c wdt.c i2c.c spim.c clock.c
    ./: hs.c
  group drvi
    ../../../platform/drvi/: drvi_init.c drvi_wktm.c drvi_uart.c drvi_i2c.c drvi_spi.c
  group init
    ./: arch_main.c
    ../../../platform/asic/6801b0/: system_init.c
  group startup
    ../../../platform/asic/6801b0/bootcode/: startup_ARMCortexM.s
target FPGA_M4f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: FPGA_M4f +hex
  AfterMake: afterbuild.bat @L !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EVB CC6801B0
  c misc: --preinclude ..\..\inc\global.h
  c include: as above
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_rom.sct
