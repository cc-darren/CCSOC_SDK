# Keil uVision project cc6801.uvprojx, settings and files
target EVB_M0p (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: EVB_M0p +hex
  AfterMake: ..\..\..\env\bin\CC_Hex2Bin.exe .\Objects\@L .\RELEASE\@L
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: EVB ZEUS_WRISTBAND APPLICATION
  c misc: --preinclude ..\..\..\cfg\project\project.h  --preinclude ..\..\..\inc\global.h
  c include: ..\..\..\ble\inc;..\..\..\ble\ip\ahi\api;..\..\..\ble\ip\ble\hl\api;..\..\..\ble\ip\ble\hl\inc;..\..\..\ble\ip\ble\hl\src\gap;..\..\..\ble\ip\ble\hl\src\gap\gapc;..\..\..\ble\ip\ble\hl\src\gap\gapm;..\..\..\ble\ip\ble\hl\src\gap\smpc;..\..\..\ble\ip\ble\hl\src\gap\smpm;..\..\..\ble\ip\ble\hl\src\gatt;..\..\..\ble\ip\ble\hl\src\gatt\attc;..\..\..\ble\ip\ble\hl\src\gatt\attm;..\..\..\ble\ip\ble\hl\src\gatt\atts;..\..\..\ble\ip\ble\hl\src\gatt\gattc;..\..\..\ble\ip\ble\hl\src\gatt\gattm;..\..\..\ble\ip\ble\hl\src\l2c\l2cc;..\..\..\ble\ip\ble\hl\src\l2c\l2cm;..\..\..\ble\ip\ble\hl\src\rwble_hl;..\..\..\ble\ip\ble\ll\src\em;..\..\..\ble\ip\ble\ll\src\llc;..\..\..\ble\ip\ble\ll\src\lld;..\..\..\ble\ip\ble\ll\src\llm;..\..\..\ble\ip\ble\ll\src\rwble;..\..\..\ble\ip\ble\profiles\anp;..\..\..\ble\ip\ble\profiles\anp\anpc\api;..\..\..\ble\ip\ble\profiles\anp\anps\api;..\..\..\ble\ip\ble\profiles\bas\basc\api;..\..\..\ble\ip\ble\profiles\bas\bass\api;..\..\..\ble\ip\ble\profiles\blp;..\..\..\ble\ip\ble\profiles\blp\blpc\api;..\..\..\ble\ip\ble\profiles\blp\blps\api;..\..\..\ble\ip\ble\profiles\cpp;..\..\..\ble\ip\ble\profiles\cpp\cppc\api;..\..\..\ble\ip\ble\profiles\cpp\cpps\api;..\..\..\ble\ip\ble\profiles\cscp;..\..\..\ble\ip\ble\profiles\cscp\cscpc\api;..\..\..\ble\ip\ble\profiles\cscp\cscps\api;..\..\..\ble\ip\ble\profiles\dis\disc\api;..\..\..\ble\ip\ble\profiles\dis\diss\api;..\..\..\ble\ip\ble\profiles\find;..\..\..\ble\ip\ble\profiles\find\findl\api;..\..\..\ble\ip\ble\profiles\find\findt\api;..\..\..\ble\ip\ble\profiles\glp;..\..\..\ble\ip\ble\profiles\glp\glpc\api;..\..\..\ble\ip\ble\profiles\glp\glps\api;..\..\..\ble\ip\ble\profiles\hogp;..\..\..\ble\ip\ble\profiles\hogp\hogpbh\api;..\..\..\ble\ip\ble\profiles\hogp\hogpd\api;..\..\..\ble\ip\ble\profiles\hogp\hogprh\api;..\..\..\ble\ip\ble\profiles\hrp;..\..\..\ble\ip\ble\profiles\hrp\hrpc\api;..\..\..\ble\ip\ble\profiles\hrp\hrps\api;..\..\..\ble\ip\ble\profiles\htp;..\..\..\ble\ip\ble\profiles\htp\htpc\api;..\..\..\ble\ip\ble\profiles\htp\htpt\api;..\..\..\ble\ip\ble\profiles\lan;..\..\..\ble\ip\ble\profiles\lan\lanc\api;..\..\..\ble\ip\ble\profiles\lan\lans\api;..\..\..\ble\ip\ble\profiles\pasp;..\..\..\ble\ip\ble\profiles\pasp\paspc\api;..\..\..\ble\ip\ble\profiles\pasp\pasps\api;..\..\..\ble\ip\ble\profiles\prox\proxm\api;..\..\..\ble\ip\ble\profiles\prox\proxr\api;..\..\..\ble\ip\ble\profiles\rscp;..\..\..\ble\ip\ble\profiles\rscp\rscpc\api;..\..\..\ble\ip\ble\profiles\rscp\rscps\api;..\..\..\ble\ip\ble\profiles\scpp;..\..\..\ble\ip\ble\profiles\scpp\scppc\api;..\..\..\ble\ip\ble\profiles\scpp\scpps\api;..\..\..\ble\ip\ble\profiles\tip;..\..\..\ble\ip\ble\profiles\tip\tipc\api;..\..\..\ble\ip\ble\profiles\tip\tips\api;..\..\..\ble\ip\ea\api;..\..\..\ble\ip\em\api;..\..\..\ble\ip\hci\api;..\..\..\ble\modules\app\api;..\..\..\ble\modules\common\api;..\..\..\ble\modules\dbg\api;..\..\..\ble\modules\display\api;..\..\..\ble\modules\ecc_p256\api;..\..\..\ble\modules\h4tl\api;..\..\..\ble\modules\ke\api;..\..\..\ble\modules\ke\src;..\..\..\ble\modules\nvds\api;..\..\..\ble\modules\rf\api;..\..\..\ble\modules\rwip\api;..\..\..\cfg;..\..\..\cfg\project;..\..\..\inc;..\..\..\inc\CMSIS;..\..\..\app;..\..\..\platform\asic\6801a0;..\..\..\platform\bootloader;..\..\..\platform\drvi;..\..\..\platform\init\inc;..\..\..\module\mems;..\..\..\module\oled;..\..\..\service\crc32;..\..\..\service\experimental_section_vars;..\..\..\service\fifo;..\..\..\service\fstorage;..\..\..\service\sw_timer;..\..\..\service\tracer;..\..\..\service\uart;..\..\..\service\fds;..\..\..\algo\CC_Library\Inc;..\..\..\algo\CC_Library\Src\Inc;..\..\..\algo\CC_Swimming\Inc;..\..\..\app\HeartRate;..\..\..\module\ppg;..\..\..\ble\modules\app\src;..\..\..\ble\modules\common\api;..\..\..\app\Display;..\..\..\ble\ip\ble\profiles\ota\otac\api;..\..\..\ble\ip\ble\profiles\ota\otat\api;..\..\..\ble\ip\ble\profiles\ota;..\..\..\ble\ip\ble\profiles\ota\otac\src;..\..\..\ble\ip\ble\profiles\ota\otat\src;..\..\..\app\DataBase;..\..\..\app\scheduler;..\..\..\app\AppService\inc;..\..\..\app\SensorController\inc;..\..\..\app\svc_mgr;..\..\..\ble\ip\ble\profiles\ccps\api;..\..\..\ble\ip\ble\profiles\ccps\src;..\..\..\app\ble_mgr;..\..\..\app\sdk\ble\profiles\ccps;..\..\..\service\fds;..\..\..\app\Vibration;..\..\..\app\utility;.\config;..\..\..\app\emWin\Config;..\..\..\app\emWin\Include;..\..\..\app\emWin\Drv;..\..\..\app\emWin\GUI_X;..\..\..\app\emWin\appwin;..\..\..\ble\ip\ble\profiles\ccps\api;..\..\..\ble\modules\app\src;..\..\..\ble\ip\ble\profiles\ccps\src;..\..\..\module\oled\JDI_LPM013MXXXX;..\ccps
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_eflash.sct
  link misc: .\rom_symdef_M0.txt  --keep=jump_table.o(jump_table_mem_area) --keep=jump_table.o(jump_table_switch_mem_area)
  group app
    ../../../app/scheduler/: scheduler.c
    ../../../app/ble_mgr/: ble_mgr.c
    ../../../app/DataBase/: database_lib_M0.lib database_lib_M4.lib
    ../../../app/Display/: font.c appDisplay.c
  group 6801a0
    ../../../platform/asic/6801a0/: clock.c dmic.c dmu.c eflash.c gpio.c i2c.c i2s.c pwm.c spim.c rtc.c uart.c wdt.c wktm.c
  group ble_app
    ../../../ble/modules/app/src/: app.c app_batt.c app_dis.c app_display.c app_hid.c app_sec.c app_task.c app_ccps.c app_ota.c app_ht.c
  group ble_drv
    ../../../ble/modules/rf/src/: rf_atlas.c
  group ble_profiles
    ../../../ble/ip/ble/hl/src/prf/: prf.c prf_utils.c
    ../../../ble/ip/ble/profiles/blp/blpc/src/: blpc.c blpc_task.c
    ../../../ble/ip/ble/profiles/blp/blps/src/: blps_task.c
    ../../../ble/ip/ble/profiles/cpp/cppc/src/: cppc.c cppc_task.c
    ../../../ble/ip/ble/profiles/cpp/cpps/src/: cpps.c cpps_task.c
    ../../../ble/ip/ble/profiles/cscp/cscpc/src/: cscpc.c cscpc_task.c
    ../../../ble/ip/ble/profiles/cscp/cscps/src/: cscps_task.c
    ../../../ble/ip/ble/profiles/dis/disc/src/: disc.c disc_task.c
    ../../../ble/ip/ble/profiles/dis/diss/src/: diss_task.c diss.c
    ../../../ble/ip/ble/profiles/find/findl/src/: findl.c findl_task.c
    ../../../ble/ip/ble/profiles/find/findt/src/: findt.c findt_task.c
    ../../../ble/ip/ble/profiles/glp/glpc/src/: glpc.c glpc_task.c
    ../../../ble/ip/ble/profiles/glp/glps/src/: glps.c glps_task.c
    ../../../ble/ip/ble/profiles/hogp/hogprh/src/: hogprh_task.c
    ../../../ble/ip/ble/profiles/hrp/hrpc/src/: hrpc.c hrpc_task.c
    ../../../ble/ip/ble/profiles/hrp/hrps/src/: hrps.c hrps_task.c
    ../../../ble/ip/ble/profiles/htp/htpc/src/: htpc.c htpc_task.c
    ../../../ble/ip/ble/profiles/htp/htpt/src/: htpt.c htpt_task.c
    ../../../ble/ip/ble/profiles/lan/lanc/src/: lanc.c lanc_task.c
    ../../../ble/ip/ble/profiles/lan/lans/src/: lans.c lans_task.c
    ../../../ble/ip/ble/profiles/pasp/paspc/src/: paspc.c paspc_task.c
    ../../../ble/ip/ble/profiles/pasp/pasps/src/: pasps.c pasps_task.c
    ../../../ble/ip/ble/profiles/prox/proxm/src/: proxm.c proxm_task.c
    ../../../ble/ip/ble/profiles/prox/proxr/src/: proxr.c proxr_task.c
    ../../../ble/ip/ble/profiles/rscp/rscpc/src/: rscpc.c rscpc_task.c
    ../../../ble/ip/ble/profiles/rscp/rscps/src/: rscps.c rscps_task.c
    ../../../ble/ip/ble/profiles/scpp/scppc/src/: scppc_task.c
    ../../../ble/ip/ble/profiles/scpp/scpps/src/: scpps.c scpps_task.c
    ../../../ble/ip/ble/profiles/tip/tipc/src/: tipc.c tipc_task.c
    ../../../ble/ip/ble/profiles/tip/tips/src/: tips.c tips_task.c
    ../../../ble/ip/ble/profiles/bas/bass/src/: bass.c bass_task.c
    ../../../ble/ip/ble/profiles/ota/otat/src/: otat.c otat_task.c
    ../../../ble/ip/ble/profiles/ccps/src/: ccps.c ccps_task.c
  group drvi
    ../../../platform/drvi/: drvi_i2c.c drvi_init.c drvi_pwm.c drvi_rtc.c drvi_spi.c drvi_uart.c drvi_wktm.c
  group fota
    ../../../platform/bootloader/: ota_handling.c
  group init
    ./: arch_main.c sdk_ccps.c
    ../../../platform/init/src/: system_init.c jump_table.c
  group oled
    ../../../module/oled/: ssd1306.c ssd1306_128x32.c sh1107.c sh1107_128x32.c
    ../../../module/oled/JDI_LPM013MXXXX/: JDI_LPM013MXXXX.c
  group service
    ../../../service/tracer/: tracer.c
    ../../../service/: service_lib_M0.lib service_lib_M4.lib
  group module
    ../../../module/mems/: acc_lsm6ds3.c acc_null.c gyr_lsm6ds3.c gyr_null.c mag_ak09912.c mag_null.c
target EVB_M4f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: EVB_M4f +hex
  AfterMake: ..\..\..\env\bin\CC_Hex2Bin.exe .\Objects\@L .\RELEASE\@L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EVB ZEUS_WRISTBAND APPLICATION
  c misc: --preinclude ..\..\..\cfg\project\project.h --preinclude ..\..\..\inc\global.h
  c include: ..\..\..\ble\inc;..\..\..\ble\ip\ahi\api;..\..\..\ble\ip\ble\hl\api;..\..\..\ble\ip\ble\hl\inc;..\..\..\ble\ip\ble\hl\src\gap;..\..\..\ble\ip\ble\hl\src\gap\gapc;..\..\..\ble\ip\ble\hl\src\gap\gapm;..\..\..\ble\ip\ble\hl\src\gap\smpc;..\..\..\ble\ip\ble\hl\src\gap\smpm;..\..\..\ble\ip\ble\hl\src\gatt;..\..\..\ble\ip\ble\hl\src\gatt\attc;..\..\..\ble\ip\ble\hl\src\gatt\attm;..\..\..\ble\ip\ble\hl\src\gatt\atts;..\..\..\ble\ip\ble\hl\src\gatt\gattc;..\..\..\ble\ip\ble\hl\src\gatt\gattm;..\..\..\ble\ip\ble\hl\src\l2c\l2cc;..\..\..\ble\ip\ble\hl\src\l2c\l2cm;..\..\..\ble\ip\ble\hl\src\rwble_hl;..\..\..\ble\ip\ble\ll\src\em;..\..\..\ble\ip\ble\ll\src\llc;..\..\..\ble\ip\ble\ll\src\lld;..\..\..\ble\ip\ble\ll\src\llm;..\..\..\ble\ip\ble\ll\src\rwble;..\..\..\ble\ip\ble\profiles\anp;..\..\..\ble\ip\ble\profiles\anp\anpc\api;..\..\..\ble\ip\ble\profiles\anp\anps\api;..\..\..\ble\ip\ble\profiles\bas\basc\api;..\..\..\ble\ip\ble\profiles\bas\bass\api;..\..\..\ble\ip\ble\profiles\blp;..\..\..\ble\ip\ble\profiles\blp\blpc\api;..\..\..\ble\ip\ble\profiles\blp\blps\api;..\..\..\ble\ip\ble\profiles\cpp;..\..\..\ble\ip\ble\profiles\cpp\cppc\api;..\..\..\ble\ip\ble\profiles\cpp\cpps\api;..\..\..\ble\ip\ble\profiles\cscp;..\..\..\ble\ip\ble\profiles\cscp\cscpc\api;..\..\..\ble\ip\ble\profiles\cscp\cscps\api;..\..\..\ble\ip\ble\profiles\dis\disc\api;..\..\..\ble\ip\ble\profiles\dis\diss\api;..\..\..\ble\ip\ble\profiles\find;..\..\..\ble\ip\ble\profiles\find\findl\api;..\..\..\ble\ip\ble\profiles\find\findt\api;..\..\..\ble\ip\ble\profiles\glp;..\..\..\ble\ip\ble\profiles\glp\glpc\api;..\..\..\ble\ip\ble\profiles\glp\glps\api;..\..\..\ble\ip\ble\profiles\hogp;..\..\..\ble\ip\ble\profiles\hogp\hogpbh\api;..\..\..\ble\ip\ble\profiles\hogp\hogpd\api;..\..\..\ble\ip\ble\profiles\hogp\hogprh\api;..\..\..\ble\ip\ble\profiles\hrp;..\..\..\ble\ip\ble\profiles\hrp\hrpc\api;..\..\..\ble\ip\ble\profiles\hrp\hrps\api;..\..\..\ble\ip\ble\profiles\htp;..\..\..\ble\ip\ble\profiles\htp\htpc\api;..\..\..\ble\ip\ble\profiles\htp\htpt\api;..\..\..\ble\ip\ble\profiles\lan;..\..\..\ble\ip\ble\profiles\lan\lanc\api;..\..\..\ble\ip\ble\profiles\lan\lans\api;..\..\..\ble\ip\ble\profiles\pasp;..\..\..\ble\ip\ble\profiles\pasp\paspc\api;..\..\..\ble\ip\ble\profiles\pasp\pasps\api;..\..\..\ble\ip\ble\profiles\prox\proxm\api;..\..\..\ble\ip\ble\profiles\prox\proxr\api;..\..\..\ble\ip\ble\profiles\rscp;..\..\..\ble\ip\ble\profiles\rscp\rscpc\api;..\..\..\ble\ip\ble\profiles\rscp\rscps\api;..\..\..\ble\ip\ble\profiles\scpp;..\..\..\ble\ip\ble\profiles\scpp\scppc\api;..\..\..\ble\ip\ble\profiles\scpp\scpps\api;..\..\..\ble\ip\ble\profiles\tip;..\..\..\ble\ip\ble\profiles\tip\tipc\api;..\..\..\ble\ip\ble\profiles\tip\tips\api;..\..\..\ble\ip\ea\api;..\..\..\ble\ip\em\api;..\..\..\ble\ip\hci\api;..\..\..\ble\modules\app\api;..\..\..\ble\modules\common\api;..\..\..\ble\modules\dbg\api;..\..\..\ble\modules\display\api;..\..\..\ble\modules\ecc_p256\api;..\..\..\ble\modules\h4tl\api;..\..\..\ble\modules\ke\api;..\..\..\ble\modules\ke\src;..\..\..\ble\modules\rf\api;..\..\..\ble\modules\rwip\api;..\..\..\service\tracer;..\..\..\cfg;..\..\..\cfg\project;..\..\..\inc;..\..\..\inc\CMSIS;..\..\..\app;..\..\..\platform\asic\6801a0;..\..\..\platform\bootloader;..\..\..\platform\drvi;..\..\..\platform\init\inc;..\..\..\module\mems;..\..\..\module\oled;..\..\..\service\crc32;..\..\..\service\experimental_section_vars;..\..\..\service\fifo;..\..\..\service\fstorage;..\..\..\service\sw_timer;..\..\..\service\uart;..\..\..\algo\CC_Library\Inc;..\..\..\algo\CC_Swimming\Inc;..\..\..\algo\HRM_Library;..\..\..\app\Display;..\..\..\app\HeartRate;..\..\..\module\ppg;..\..\..\algo\CC_Library\Src\Inc;..\..\..\ble\modules\app\src;..\..\..\ble\ip\ble\profiles\ota\otat;..\..\..\ble\ip\ble\profiles\ota\otat\api;..\..\..\ble\ip\ble\profiles\ota\otat\src;..\..\..\app\DataBase;..\..\..\service\fds;..\..\..\app\scheduler;..\..\..\app\SensorController\inc;..\..\..\app\AppService\inc;..\..\..\app\svc_mgr;..\..\..\ble\ip\ble\profiles\ccps\api;..\..\..\ble\ip\ble\profiles\ccps\src;..\..\..\app\ble_mgr;..\..\..\app\sdk\ble\profiles\ccps;..\..\..\app\sdk\database;..\..\..\app\DataBase;..\..\..\app\Vibration;..\..\..\app\utility;.\config;..\..\..\app\emWin\Config;..\..\..\app\emWin\Include;..\..\..\app\emWin\Drv;..\..\..\app\emWin\GUI_X;..\..\..\app\emWin\appwin;..\..\..\ble\ip\ble\profiles\ccps\api;..\..\..\ble\modules\app\src;..\..\..\ble\ip\ble\profiles\ccps\src;..\..\..\module\oled\JDI_LPM013MXXXX;..\..\..\ble\ip\ble\profiles\htp\htpt\api;..\..\..\ble\ip\ble\profiles\htp\htpt\src;..\ccps
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_eflash.sct
  link misc: .\rom_symdef_M4.txt --keep=jump_table.o(jump_table_mem_area) --keep=jump_table.o(jump_table_switch_mem_area)
target EVB_QFN60L_M0p (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: EVB_M0p +hex
  AfterMake: ..\..\..\env\bin\CC_Hex2Bin.exe .\Objects\@L .\RELEASE\@L
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: EVB_QFN60L ZEUS_WRISTBAND APPLICATION
  c misc: as above
  c include: ..\..\..\ble\inc;..\..\..\ble\ip\ahi\api;..\..\..\ble\ip\ble\hl\api;..\..\..\ble\ip\ble\hl\inc;..\..\..\ble\ip\ble\hl\src\gap;..\..\..\ble\ip\ble\hl\src\gap\gapc;..\..\..\ble\ip\ble\hl\src\gap\gapm;..\..\..\ble\ip\ble\hl\src\gap\smpc;..\..\..\ble\ip\ble\hl\src\gap\smpm;..\..\..\ble\ip\ble\hl\src\gatt;..\..\..\ble\ip\ble\hl\src\gatt\attc;..\..\..\ble\ip\ble\hl\src\gatt\attm;..\..\..\ble\ip\ble\hl\src\gatt\atts;..\..\..\ble\ip\ble\hl\src\gatt\gattc;..\..\..\ble\ip\ble\hl\src\gatt\gattm;..\..\..\ble\ip\ble\hl\src\l2c\l2cc;..\..\..\ble\ip\ble\hl\src\l2c\l2cm;..\..\..\ble\ip\ble\hl\src\rwble_hl;..\..\..\ble\ip\ble\ll\src\em;..\..\..\ble\ip\ble\ll\src\llc;..\..\..\ble\ip\ble\ll\src\lld;..\..\..\ble\ip\ble\ll\src\llm;..\..\..\ble\ip\ble\ll\src\rwble;..\..\..\ble\ip\ble\profiles\anp;..\..\..\ble\ip\ble\profiles\anp\anpc\api;..\..\..\ble\ip\ble\profiles\anp\anps\api;..\..\..\ble\ip\ble\profiles\bas\basc\api;..\..\..\ble\ip\ble\profiles\bas\bass\api;..\..\..\ble\ip\ble\profiles\blp;..\..\..\ble\ip\ble\profiles\blp\blpc\api;..\..\..\ble\ip\ble\profiles\blp\blps\api;..\..\..\ble\ip\ble\profiles\cpp;..\..\..\ble\ip\ble\profiles\cpp\cppc\api;..\..\..\ble\ip\ble\profiles\cpp\cpps\api;..\..\..\ble\ip\ble\profiles\cscp;..\..\..\ble\ip\ble\profiles\cscp\cscpc\api;..\..\..\ble\ip\ble\profiles\cscp\cscps\api;..\..\..\ble\ip\ble\profiles\dis\disc\api;..\..\..\ble\ip\ble\profiles\dis\diss\api;..\..\..\ble\ip\ble\profiles\find;..\..\..\ble\ip\ble\profiles\find\findl\api;..\..\..\ble\ip\ble\profiles\find\findt\api;..\..\..\ble\ip\ble\profiles\glp;..\..\..\ble\ip\ble\profiles\glp\glpc\api;..\..\..\ble\ip\ble\profiles\glp\glps\api;..\..\..\ble\ip\ble\profiles\hogp;..\..\..\ble\ip\ble\profiles\hogp\hogpbh\api;..\..\..\ble\ip\ble\profiles\hogp\hogpd\api;..\..\..\ble\ip\ble\profiles\hogp\hogprh\api;..\..\..\ble\ip\ble\profiles\hrp;..\..\..\ble\ip\ble\profiles\hrp\hrpc\api;..\..\..\ble\ip\ble\profiles\hrp\hrps\api;..\..\..\ble\ip\ble\profiles\htp;..\..\..\ble\ip\ble\profiles\htp\htpc\api;..\..\..\ble\ip\ble\profiles\htp\htpt\api;..\..\..\ble\ip\ble\profiles\lan;..\..\..\ble\ip\ble\profiles\lan\lanc\api;..\..\..\ble\ip\ble\profiles\lan\lans\api;..\..\..\ble\ip\ble\profiles\pasp;..\..\..\ble\ip\ble\profiles\pasp\paspc\api;..\..\..\ble\ip\ble\profiles\pasp\pasps\api;..\..\..\ble\ip\ble\profiles\prox\proxm\api;..\..\..\ble\ip\ble\profiles\prox\proxr\api;..\..\..\ble\ip\ble\profiles\rscp;..\..\..\ble\ip\ble\profiles\rscp\rscpc\api;..\..\..\ble\ip\ble\profiles\rscp\rscps\api;..\..\..\ble\ip\ble\profiles\scpp;..\..\..\ble\ip\ble\profiles\scpp\scppc\api;..\..\..\ble\ip\ble\profiles\scpp\scpps\api;..\..\..\ble\ip\ble\profiles\tip;..\..\..\ble\ip\ble\profiles\tip\tipc\api;..\..\..\ble\ip\ble\profiles\tip\tips\api;..\..\..\ble\ip\ea\api;..\..\..\ble\ip\em\api;..\..\..\ble\ip\hci\api;..\..\..\ble\modules\app\api;..\..\..\ble\modules\common\api;..\..\..\ble\modules\dbg\api;..\..\..\ble\modules\display\api;..\..\..\ble\modules\ecc_p256\api;..\..\..\ble\modules\h4tl\api;..\..\..\ble\modules\ke\api;..\..\..\ble\modules\ke\src;..\..\..\ble\modules\nvds\api;..\..\..\ble\modules\rf\api;..\..\..\ble\modules\rwip\api;..\..\..\cfg;..\..\..\cfg\project;..\..\..\inc;..\..\..\inc\CMSIS;..\..\..\app;..\..\..\platform\asic\6801a0;..\..\..\platform\bootloader;..\..\..\platform\drvi;..\..\..\platform\init\inc;..\..\..\module\mems;..\..\..\module\oled;..\..\..\service\crc32;..\..\..\service\experimental_section_vars;..\..\..\service\fifo;..\..\..\service\fstorage;..\..\..\service\sw_timer;..\..\..\service\tracer;..\..\..\service\uart;..\..\..\service\fds;..\..\..\algo\CC_Library\Inc;..\..\..\algo\CC_Library\Src\Inc;..\..\..\algo\CC_Swimming\Inc;..\..\..\app\HeartRate;..\..\..\module\ppg;..\..\..\ble\modules\app\src;..\..\..\ble\modules\common\api;..\..\..\app\Display;..\..\..\ble\ip\ble\profiles\ota\otac\api;..\..\..\ble\ip\ble\profiles\ota\otat\api;..\..\..\ble\ip\ble\profiles\ota;..\..\..\ble\ip\ble\profiles\ota\otac\src;..\..\..\ble\ip\ble\profiles\ota\otat\src;..\..\..\app\DataBase;..\..\..\app\scheduler;..\..\..\app\AppService\inc;..\..\..\app\SensorController\inc;..\..\..\app\svc_mgr;..\..\..\ble\ip\ble\profiles\ccps\api;..\..\..\ble\ip\ble\profiles\ccps\src;..\..\..\app\ble_mgr;..\..\..\app\sdk\ble\profiles\ccps;..\..\..\service\fds;..\..\..\app\Vibration;..\..\..\app\utility;.\config;..\..\..\app\emWin\Config;..\..\..\app\emWin\Include;..\..\..\app\emWin\Drv;..\..\..\app\emWin\GUI_X;..\..\..\app\emWin\appwin;..\..\..\ble\ip\ble\profiles\ccps\api;..\..\..\ble\modules\app\src;..\..\..\ble\ip\ble\profiles\ccps\src;..\..\..\module\oled\JDI_LPM013MXXXX;..\..\..\app\sdk\database;..\..\..\app\HeartRate;..\ccps
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_eflash.sct
  link misc: as above
target EVB_QFN60L_M4f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: EVB_M4f +hex
  AfterMake: ..\..\..\env\bin\CC_Hex2Bin.exe .\Objects\@L .\RELEASE\@L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EVB_QFN60L ZEUS_WRISTBAND APPLICATION
  c misc: as above
  c include: ..\..\..\ble\inc;..\..\..\ble\ip\ahi\api;..\..\..\ble\ip\ble\hl\api;..\..\..\ble\ip\ble\hl\inc;..\..\..\ble\ip\ble\hl\src\gap;..\..\..\ble\ip\ble\hl\src\gap\gapc;..\..\..\ble\ip\ble\hl\src\gap\gapm;..\..\..\ble\ip\ble\hl\src\gap\smpc;..\..\..\ble\ip\ble\hl\src\gap\smpm;..\..\..\ble\ip\ble\hl\src\gatt;..\..\..\ble\ip\ble\hl\src\gatt\attc;..\..\..\ble\ip\ble\hl\src\gatt\attm;..\..\..\ble\ip\ble\hl\src\gatt\atts;..\..\..\ble\ip\ble\hl\src\gatt\gattc;..\..\..\ble\ip\ble\hl\src\gatt\gattm;..\..\..\ble\ip\ble\hl\src\l2c\l2cc;..\..\..\ble\ip\ble\hl\src\l2c\l2cm;..\..\..\ble\ip\ble\hl\src\rwble_hl;..\..\..\ble\ip\ble\ll\src\em;..\..\..\ble\ip\ble\ll\src\llc;..\..\..\ble\ip\ble\ll\src\lld;..\..\..\ble\ip\ble\ll\src\llm;..\..\..\ble\ip\ble\ll\src\rwble;..\..\..\ble\ip\ble\profiles\anp;..\..\..\ble\ip\ble\profiles\anp\anpc\api;..\..\..\ble\ip\ble\profiles\anp\anps\api;..\..\..\ble\ip\ble\profiles\bas\basc\api;..\..\..\ble\ip\ble\profiles\bas\bass\api;..\..\..\ble\ip\ble\profiles\blp;..\..\..\ble\ip\ble\profiles\blp\blpc\api;..\..\..\ble\ip\ble\profiles\blp\blps\api;..\..\..\ble\ip\ble\profiles\cpp;..\..\..\ble\ip\ble\profiles\cpp\cppc\api;..\..\..\ble\ip\ble\profiles\cpp\cpps\api;..\..\..\ble\ip\ble\profiles\cscp;..\..\..\ble\ip\ble\profiles\cscp\cscpc\api;..\..\..\ble\ip\ble\profiles\cscp\cscps\api;..\..\..\ble\ip\ble\profiles\dis\disc\api;..\..\..\ble\ip\ble\profiles\dis\diss\api;..\..\..\ble\ip\ble\profiles\find;..\..\..\ble\ip\ble\profiles\find\findl\api;..\..\..\ble\ip\ble\profiles\find\findt\api;..\..\..\ble\ip\ble\profiles\glp;..\..\..\ble\ip\ble\profiles\glp\glpc\api;..\..\..\ble\ip\ble\profiles\glp\glps\api;..\..\..\ble\ip\ble\profiles\hogp;..\..\..\ble\ip\ble\profiles\hogp\hogpbh\api;..\..\..\ble\ip\ble\profiles\hogp\hogpd\api;..\..\..\ble\ip\ble\profiles\hogp\hogprh\api;..\..\..\ble\ip\ble\profiles\hrp;..\..\..\ble\ip\ble\profiles\hrp\hrpc\api;..\..\..\ble\ip\ble\profiles\hrp\hrps\api;..\..\..\ble\ip\ble\profiles\htp;..\..\..\ble\ip\ble\profiles\htp\htpc\api;..\..\..\ble\ip\ble\profiles\htp\htpt\api;..\..\..\ble\ip\ble\profiles\lan;..\..\..\ble\ip\ble\profiles\lan\lanc\api;..\..\..\ble\ip\ble\profiles\lan\lans\api;..\..\..\ble\ip\ble\profiles\pasp;..\..\..\ble\ip\ble\profiles\pasp\paspc\api;..\..\..\ble\ip\ble\profiles\pasp\pasps\api;..\..\..\ble\ip\ble\profiles\prox\proxm\api;..\..\..\ble\ip\ble\profiles\prox\proxr\api;..\..\..\ble\ip\ble\profiles\rscp;..\..\..\ble\ip\ble\profiles\rscp\rscpc\api;..\..\..\ble\ip\ble\profiles\rscp\rscps\api;..\..\..\ble\ip\ble\profiles\scpp;..\..\..\ble\ip\ble\profiles\scpp\scppc\api;..\..\..\ble\ip\ble\profiles\scpp\scpps\api;..\..\..\ble\ip\ble\profiles\tip;..\..\..\ble\ip\ble\profiles\tip\tipc\api;..\..\..\ble\ip\ble\profiles\tip\tips\api;..\..\..\ble\ip\ea\api;..\..\..\ble\ip\em\api;..\..\..\ble\ip\hci\api;..\..\..\ble\modules\app\api;..\..\..\ble\modules\common\api;..\..\..\ble\modules\dbg\api;..\..\..\ble\modules\display\api;..\..\..\ble\modules\ecc_p256\api;..\..\..\ble\modules\h4tl\api;..\..\..\ble\modules\ke\api;..\..\..\ble\modules\ke\src;..\..\..\ble\modules\nvds\api;..\..\..\ble\modules\rf\api;..\..\..\ble\modules\rwip\api;..\..\..\service\tracer;..\..\..\cfg;..\..\..\cfg\project;..\..\..\inc;..\..\..\inc\CMSIS;..\..\..\app;..\..\..\platform\asic\6801a0;..\..\..\platform\bootloader;..\..\..\platform\drvi;..\..\..\platform\init\inc;..\..\..\module\mems;..\..\..\module\oled;..\..\..\service\crc32;..\..\..\service\experimental_section_vars;..\..\..\service\fifo;..\..\..\service\fstorage;..\..\..\service\sw_timer;..\..\..\service\uart;..\..\..\algo\CC_Library\Inc;..\..\..\algo\CC_Swimming\Inc;..\..\..\algo\HRM_Library;..\..\..\app\Display;..\..\..\app\HeartRate;..\..\..\module\ppg;..\..\..\algo\CC_Library\Src\Inc;..\..\..\ble\modules\app\src;..\..\..\ble\ip\ble\profiles\ota\otat;..\..\..\ble\ip\ble\profiles\ota\otat\api;..\..\..\ble\ip\ble\profiles\ota\otat\src;..\..\..\app\DataBase;..\..\..\service\fds;..\..\..\app\scheduler;..\..\..\app\SensorController\inc;..\..\..\app\AppService\inc;..\..\..\app\svc_mgr;..\..\..\ble\ip\ble\profiles\ccps\api;..\..\..\ble\ip\ble\profiles\ccps\src;..\..\..\app\ble_mgr;..\..\..\app\sdk\ble\profiles\ccps;..\..\..\app\sdk\database;..\..\..\app\DataBase;..\..\..\app\Vibration;..\..\..\app\utility;.\config;..\..\..\app\emWin\Config;..\..\..\app\emWin\Include;..\..\..\app\emWin\Drv;..\..\..\app\emWin\GUI_X;..\..\..\app\emWin\appwin;..\..\..\ble\ip\ble\profiles\ccps\api;..\..\..\ble\modules\app\src;..\..\..\ble\ip\ble\profiles\ccps\src;..\..\..\module\oled\JDI_LPM013MXXXX;..\ccps
  asm misc: --cpreproc
  asm include: .\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT6: RAM 0x40000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20020000 size 0x2000
  scatter file: .\FPGA_eflash.sct
  link misc: as above
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
