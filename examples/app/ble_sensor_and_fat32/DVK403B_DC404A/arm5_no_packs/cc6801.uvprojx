# Keil uVision project cc6801.uvprojx, settings and files
target DVK_DC404A_M0p (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: DVK_DC404A_M0 +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK_DC404A CC6801B1 FREERTOS
  c misc: --preinclude ..\..\..\..\..\cfg\project\project.h --preinclude ..\..\..\..\..\inc\global.h
  c include: ..\config;..\..\..\..\..\cfg\project;..\..\..\..\..\inc;..\..\..\..\..\inc\CMSIS;..\..\..\..\..\platform\init\inc;..\..\..\..\..\platform\asic\6801b1;..\..\..\..\..\platform\drvi;..\..\..\..\..\service\tracer;..\..\..\..\..\service\uart_ring;..\..\..\..\..\service\sw_timer;..\..\..\..\..\platform\rtos\freertos\include;..\..\..\..\..\platform\rtos\freertos\portable\RVDS\ARM_CM0;..\..\..\..\..\ble\inc;..\..\..\..\..\ble\ip\ahi\api;..\..\..\..\..\ble\ip\ble\hl\api;..\..\..\..\..\ble\ip\ble\hl\inc;..\..\..\..\..\ble\ip\ble\hl\src\gap;..\..\..\..\..\ble\ip\ble\hl\src\gap\gapc;..\..\..\..\..\ble\ip\ble\hl\src\gap\gapm;..\..\..\..\..\ble\ip\ble\hl\src\gap\smpc;..\..\..\..\..\ble\ip\ble\hl\src\gap\smpm;..\..\..\..\..\ble\ip\ble\hl\src\gatt;..\..\..\..\..\ble\ip\ble\hl\src\gatt\attc;..\..\..\..\..\ble\ip\ble\hl\src\gatt\attm;..\..\..\..\..\ble\ip\ble\hl\src\gatt\atts;..\..\..\..\..\ble\ip\ble\hl\src\gatt\gattc;..\..\..\..\..\ble\ip\ble\hl\src\gatt\gattm;..\..\..\..\..\ble\ip\ble\hl\src\l2c\l2cc;..\..\..\..\..\ble\ip\ble\hl\src\l2c\l2cm;..\..\..\..\..\ble\ip\ble\hl\src\rwble_hl;..\..\..\..\..\ble\ip\ble\ll\src\em;..\..\..\..\..\ble\ip\ble\ll\src\llc;..\..\..\..\..\ble\ip\ble\ll\src\lld;..\..\..\..\..\ble\ip\ble\ll\src\llm;..\..\..\..\..\ble\ip\ble\ll\src\rwble;..\..\..\..\..\ble\ip\ble\profiles\anp;..\..\..\..\..\ble\ip\ble\profiles\anp\anpc\api;..\..\..\..\..\ble\ip\ble\profiles\anp\anps\api;..\..\..\..\..\ble\ip\ble\profiles\bas\basc\api;..\..\..\..\..\ble\ip\ble\profiles\bas\bass\api;..\..\..\..\..\ble\ip\ble\profiles\blp;..\..\..\..\..\ble\ip\ble\profiles\blp\blpc\api;..\..\..\..\..\ble\ip\ble\profiles\blp\blps\api;..\..\..\..\..\ble\ip\ble\profiles\cpp;..\..\..\..\..\ble\ip\ble\profiles\cpp\cppc\api;..\..\..\..\..\ble\ip\ble\profiles\cpp\cpps\api;..\..\..\..\..\ble\ip\ble\profiles\cscp;..\..\..\..\..\ble\ip\ble\profiles\cscp\cscpc\api;..\..\..\..\..\ble\ip\ble\profiles\cscp\cscps\api;..\..\..\..\..\ble\ip\ble\profiles\dis\disc\api;..\..\..\..\..\ble\ip\ble\profiles\dis\diss\api;..\..\..\..\..\ble\ip\ble\profiles\find;..\..\..\..\..\ble\ip\ble\profiles\find\findl\api;..\..\..\..\..\ble\ip\ble\profiles\find\findt\api;..\..\..\..\..\ble\ip\ble\profiles\glp;..\..\..\..\..\ble\ip\ble\profiles\glp\glpc\api;..\..\..\..\..\ble\ip\ble\profiles\glp\glps\api;..\..\..\..\..\ble\ip\ble\profiles\hogp;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogpbh\api;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogpd\api;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogprh\api;..\..\..\..\..\ble\ip\ble\profiles\hrp;..\..\..\..\..\ble\ip\ble\profiles\hrp\hrpc\api;..\..\..\..\..\ble\ip\ble\profiles\hrp\hrps\api;..\..\..\..\..\ble\ip\ble\profiles\htp;..\..\..\..\..\ble\ip\ble\profiles\htp\htpc\api;..\..\..\..\..\ble\ip\ble\profiles\htp\htpt\api;..\..\..\..\..\ble\ip\ble\profiles\lan;..\..\..\..\..\ble\ip\ble\profiles\lan\lanc\api;..\..\..\..\..\ble\ip\ble\profiles\lan\lans\api;..\..\..\..\..\ble\ip\ble\profiles\pasp;..\..\..\..\..\ble\ip\ble\profiles\pasp\paspc\api;..\..\..\..\..\ble\ip\ble\profiles\pasp\pasps\api;..\..\..\..\..\ble\ip\ble\profiles\prox\proxm\api;..\..\..\..\..\ble\ip\ble\profiles\prox\proxr\api;..\..\..\..\..\ble\ip\ble\profiles\rscp;..\..\..\..\..\ble\ip\ble\profiles\rscp\rscpc\api;..\..\..\..\..\ble\ip\ble\profiles\rscp\rscps\api;..\..\..\..\..\ble\ip\ble\profiles\scpp;..\..\..\..\..\ble\ip\ble\profiles\scpp\scppc\api;..\..\..\..\..\ble\ip\ble\profiles\scpp\scpps\api;..\..\..\..\..\ble\ip\ble\profiles\tip;..\..\..\..\..\ble\ip\ble\profiles\tip\tipc\api;..\..\..\..\..\ble\ip\ble\profiles\tip\tips\api;..\..\..\..\..\ble\ip\ea\api;..\..\..\..\..\ble\ip\em\api;..\..\..\..\..\ble\ip\hci\api;..\..\..\..\..\ble\modules\app\api;..\..\..\..\..\ble\modules\common\api;..\..\..\..\..\ble\modules\dbg\api;..\..\..\..\..\ble\modules\display\api;..\..\..\..\..\ble\modules\ecc_p256\api;..\..\..\..\..\ble\modules\h4tl\api;..\..\..\..\..\ble\modules\ke\api;..\..\..\..\..\ble\modules\ke\src;..\..\..\..\..\ble\modules\nvds\api;..\..\..\..\..\ble\modules\rf\api;..\..\..\..\..\ble\modules\rwip\api;..\..\..\..\..\ble\modules\app\src;..\..\..\..\..\ble\ip\ble\profiles\ota\otat;..\..\..\..\..\ble\ip\ble\profiles\ota\otat\api;..\..\..\..\..\ble\ip\ble\profiles\ota\otat\src;..\..\..\..\..\ble\ip\ble\profiles\ccps\api;..\..\..\..\..\ble\ip\ble\profiles\ccps\src;..\..\..\..\..\app\ble_mgr;..\..\..\..\..\platform\bootloader;..\ble_sensor_and_fat32;..\..\..\..\..\module\mems;..\..\..\..\..\platform\rtos\freertos_fat\include;..\..\..\..\..\platform\rtos\freertos_fat\portable\cc6801;..\..\..\..\..\module\flash
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\eflash.sct
  link misc: ..\..\..\..\..\platform\asic\6801b1\rom_symdef_M0.txt --keep=jump_table.o(jump_table_mem_area) --diag_suppress=L6314
  group 6801b1
    ../../../../../platform/asic/6801b1/: clock.c gpio.c uart.c system_init.c i2c.c pwm.c wktm.c spim.c eflash.c wdt.c
    ../../../../../platform/bootloader/: ota_handling.c
  group drvi
    ../../../../../platform/drvi/: drvi_init.c drvi_uart.c drvi_i2c.c drvi_pwm.c drvi_spi.c drvi_wktm.c
  group module
    ../../../../../module/mems/: gyr_null.c mag_null.c acc_lsm6ds3.c acc_null.c
    ../../../../../module/touch/: touch_null.c
    ../../../../../module/flash/: flash_winbond.c
  group service
    ../../../../../service/: service_lib_M0.lib service_lib_M4.lib
    ../../../../../service/tracer/: tracer.c
  group startup
    ../../: arch_main.c
    ../../../../../platform/asic/6801b1/bootcode/: startup_ARMCortexM.s
    ../../../../../platform/init/src/: jump_table.c
    ./: task_table.c
  group fat
    ../../../../../platform/rtos/freertos_fat/: ff_crc.c ff_dir.c ff_error.c ff_fat.c ff_file.c ff_format.c ff_ioman.c ff_locking.c ff_memory.c ff_stdio.c ff_string.c ff_sys.c ff_time.c
    ../../../../../platform/rtos/freertos_fat/portable/cc6801/: ff_spidisk.c
  group rtos
    ../../../../../platform/rtos/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../platform/rtos/freertos/portable/MemMang/: heap_4.c
    ../../../../../platform/rtos/freertos/portable/RVDS/ARM_CM0/: port_CM0.c
    ../../../../../platform/rtos/freertos/portable/RVDS/ARM_CM4F/: port_CM4F.c
  group app
    ../../../../../app/ble_mgr/: ble_mgr.c
  group ble_app
    ../../../../../ble/modules/app/src/: app.c app_batt.c app_ccps.c app_dis.c app_ota.c app_sec.c app_task.c
  group ble_drv
    ../../../../../ble/modules/rf/src/: rf_atlas.c
    ../../../../../ble/modules/nvds/src/: nvds.c
  group ble_profiles
    ../../../../../ble/ip/ble/profiles/bas/bass/src/: bass.c bass_task.c
    ../../../../../ble/ip/ble/profiles/ccps/src/: ccps.c ccps_task.c
    ../../../../../ble/ip/ble/profiles/dis/diss/src/: diss.c diss_task.c
    ../../../../../ble/ip/ble/profiles/ota/otat/src/: otat.c otat_task.c
    ../../../../../ble/ip/ble/hl/src/prf/: prf.c prf_utils.c
target DVK_DC404A_M4f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: DVK_DC404A_M4f +hex
  AfterMake: ..\..\..\..\..\env\bin\afterbuild.bat @L !L #K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DVK_DC404A CC6801B1 FREERTOS
  c misc: as above
  c include: ..\config;..\..\..\..\..\cfg\project;..\..\..\..\..\inc;..\..\..\..\..\inc\CMSIS;..\..\..\..\..\platform\init\inc;..\..\..\..\..\platform\asic\6801b1;..\..\..\..\..\platform\drvi;..\..\..\..\..\service\tracer;..\..\..\..\..\service\uart_ring;..\..\..\..\..\service\sw_timer;..\..\..\..\..\platform\rtos\freertos\include;..\..\..\..\..\platform\rtos\freertos\portable\RVDS\ARM_CM4F;..\..\..\..\..\ble\inc;..\..\..\..\..\ble\ip\ahi\api;..\..\..\..\..\ble\ip\ble\hl\api;..\..\..\..\..\ble\ip\ble\hl\inc;..\..\..\..\..\ble\ip\ble\hl\src\gap;..\..\..\..\..\ble\ip\ble\hl\src\gap\gapc;..\..\..\..\..\ble\ip\ble\hl\src\gap\gapm;..\..\..\..\..\ble\ip\ble\hl\src\gap\smpc;..\..\..\..\..\ble\ip\ble\hl\src\gap\smpm;..\..\..\..\..\ble\ip\ble\hl\src\gatt;..\..\..\..\..\ble\ip\ble\hl\src\gatt\attc;..\..\..\..\..\ble\ip\ble\hl\src\gatt\attm;..\..\..\..\..\ble\ip\ble\hl\src\gatt\atts;..\..\..\..\..\ble\ip\ble\hl\src\gatt\gattc;..\..\..\..\..\ble\ip\ble\hl\src\gatt\gattm;..\..\..\..\..\ble\ip\ble\hl\src\l2c\l2cc;..\..\..\..\..\ble\ip\ble\hl\src\l2c\l2cm;..\..\..\..\..\ble\ip\ble\hl\src\rwble_hl;..\..\..\..\..\ble\ip\ble\ll\src\em;..\..\..\..\..\ble\ip\ble\ll\src\llc;..\..\..\..\..\ble\ip\ble\ll\src\lld;..\..\..\..\..\ble\ip\ble\ll\src\llm;..\..\..\..\..\ble\ip\ble\ll\src\rwble;..\..\..\..\..\ble\ip\ble\profiles\anp;..\..\..\..\..\ble\ip\ble\profiles\anp\anpc\api;..\..\..\..\..\ble\ip\ble\profiles\anp\anps\api;..\..\..\..\..\ble\ip\ble\profiles\bas\basc\api;..\..\..\..\..\ble\ip\ble\profiles\bas\bass\api;..\..\..\..\..\ble\ip\ble\profiles\blp;..\..\..\..\..\ble\ip\ble\profiles\blp\blpc\api;..\..\..\..\..\ble\ip\ble\profiles\blp\blps\api;..\..\..\..\..\ble\ip\ble\profiles\cpp;..\..\..\..\..\ble\ip\ble\profiles\cpp\cppc\api;..\..\..\..\..\ble\ip\ble\profiles\cpp\cpps\api;..\..\..\..\..\ble\ip\ble\profiles\cscp;..\..\..\..\..\ble\ip\ble\profiles\cscp\cscpc\api;..\..\..\..\..\ble\ip\ble\profiles\cscp\cscps\api;..\..\..\..\..\ble\ip\ble\profiles\dis\disc\api;..\..\..\..\..\ble\ip\ble\profiles\dis\diss\api;..\..\..\..\..\ble\ip\ble\profiles\find;..\..\..\..\..\ble\ip\ble\profiles\find\findl\api;..\..\..\..\..\ble\ip\ble\profiles\find\findt\api;..\..\..\..\..\ble\ip\ble\profiles\glp;..\..\..\..\..\ble\ip\ble\profiles\glp\glpc\api;..\..\..\..\..\ble\ip\ble\profiles\glp\glps\api;..\..\..\..\..\ble\ip\ble\profiles\hogp;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogpbh\api;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogpd\api;..\..\..\..\..\ble\ip\ble\profiles\hogp\hogprh\api;..\..\..\..\..\ble\ip\ble\profiles\hrp;..\..\..\..\..\ble\ip\ble\profiles\hrp\hrpc\api;..\..\..\..\..\ble\ip\ble\profiles\hrp\hrps\api;..\..\..\..\..\ble\ip\ble\profiles\htp;..\..\..\..\..\ble\ip\ble\profiles\htp\htpc\api;..\..\..\..\..\ble\ip\ble\profiles\htp\htpt\api;..\..\..\..\..\ble\ip\ble\profiles\lan;..\..\..\..\..\ble\ip\ble\profiles\lan\lanc\api;..\..\..\..\..\ble\ip\ble\profiles\lan\lans\api;..\..\..\..\..\ble\ip\ble\profiles\pasp;..\..\..\..\..\ble\ip\ble\profiles\pasp\paspc\api;..\..\..\..\..\ble\ip\ble\profiles\pasp\pasps\api;..\..\..\..\..\ble\ip\ble\profiles\prox\proxm\api;..\..\..\..\..\ble\ip\ble\profiles\prox\proxr\api;..\..\..\..\..\ble\ip\ble\profiles\rscp;..\..\..\..\..\ble\ip\ble\profiles\rscp\rscpc\api;..\..\..\..\..\ble\ip\ble\profiles\rscp\rscps\api;..\..\..\..\..\ble\ip\ble\profiles\scpp;..\..\..\..\..\ble\ip\ble\profiles\scpp\scppc\api;..\..\..\..\..\ble\ip\ble\profiles\scpp\scpps\api;..\..\..\..\..\ble\ip\ble\profiles\tip;..\..\..\..\..\ble\ip\ble\profiles\tip\tipc\api;..\..\..\..\..\ble\ip\ble\profiles\tip\tips\api;..\..\..\..\..\ble\ip\ea\api;..\..\..\..\..\ble\ip\em\api;..\..\..\..\..\ble\ip\hci\api;..\..\..\..\..\ble\modules\app\api;..\..\..\..\..\ble\modules\common\api;..\..\..\..\..\ble\modules\dbg\api;..\..\..\..\..\ble\modules\display\api;..\..\..\..\..\ble\modules\ecc_p256\api;..\..\..\..\..\ble\modules\h4tl\api;..\..\..\..\..\ble\modules\ke\api;..\..\..\..\..\ble\modules\ke\src;..\..\..\..\..\ble\modules\nvds\api;..\..\..\..\..\ble\modules\rf\api;..\..\..\..\..\ble\modules\rwip\api;..\..\..\..\..\ble\modules\app\src;..\..\..\..\..\ble\ip\ble\profiles\ota\otat;..\..\..\..\..\ble\ip\ble\profiles\ota\otat\api;..\..\..\..\..\ble\ip\ble\profiles\ota\otat\src;..\..\..\..\..\ble\ip\ble\profiles\ccps\api;..\..\..\..\..\ble\ip\ble\profiles\ccps\src;..\..\..\..\..\app\ble_mgr;..\..\..\..\..\platform\bootloader;..\ble_sensor_and_fat32;..\..\..\..\..\module\mems;..\..\..\..\..\platform\rtos\freertos_fat\include;..\..\..\..\..\platform\rtos\freertos_fat\portable\cc6801;..\..\..\..\..\module\flash
  asm misc: --cpreproc
  asm include: ..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\eflash.sct
  link misc: ..\..\..\..\..\platform\asic\6801b1\rom_symdef_M4.txt --keep=jump_table.o(jump_table_mem_area) --diag_suppress=L6314
